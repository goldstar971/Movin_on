# Repository goldstar971/Movin_on (continued)

## KiCad design kicad_files/Forward_acceleration_board/Forward_acceleration_board.kicad_pcb

Board: 4 copper layers, 203.2 x 228.6 mm, 90 parts (12 on the bottom side), 49 nets.

Parts:
AMP1, AMP2: MCP6054+E_SL; SOIC127P600X175-14N
Accel_mc1: STM32F205RBT6; QFP50P1200X1200X160-64N
BUSCNT1: SM05B-PASS-TBT(LF)(SN); SM05BPASSTBTLFSN
C1, C2, C19: 1u; CAPC1005X55N
C3, C4, C9, C10, C11, C17, C18, C20, C21, C23, C25, C26, C32: .1u; CAPC2012X145N
C5, C6, C7, C8, C14, C15, C16: 47p; CAPC1005X55N
C12, C13, C22: 4.7u; CAPC3225X200N
C24, C27: 2.2u; CAPC3216X180N
C28, C30: .1u; CAPC1005X55N
C29: 10u; CAPC2012X145N
C31: 100n; CAPC2012X145N
CAN_TR1: SN65HVD232DR; SOIC127P600X175-8N
DAC1, DAC2: MAX5815BAUD+; SOP65P640X110-14N
IMU1: LIS2DTW12TR; IIS2MDCTR
J3, J4, J5, J6, J7, J8, J9, J10, J11, J12, J13, J14, J15, J16: Conn_01x01_Male; SolderWirePad_1x01_SMD_1.27x2.54mm
R1, R5, R9, R12, R13, R14, R16, R17, R21, R25, R29, R33, R34: 5k; RESC1608X55N
R2, R6, R10, R18, R22, R26, R30: 20k; RESC1608X55N
R3, R7, R11, R19, R23, R27, R31: 100k; RESC1608X55N
R4, R8, R15, R20, R24, R28, R32: 50k; RESC1608X55N
Reg1: TC2117; SOT230P700X180-4N
SWD1: SM04B-PASS-TBT(LF)(SN); SM04B-PASS-TBT

Connections:
+3V3: AMP1.4, AMP1.12, AMP2.4, Accel_mc1.1, Accel_mc1.13, Accel_mc1.19, Accel_mc1.32, Accel_mc1.48, Accel_mc1.64, BUSCNT1.1, C1.1, C3.1, C4.1, C9.1, C10.1, C11.1, C12.1, C13.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C25.1, C26.1, C28.1, C29.1, C30.1, C31.1, C32.1, CAN_TR1.3, DAC1.7, DAC1.12, DAC1.13, DAC1.14, DAC2.7, DAC2.8, DAC2.12, DAC2.13, DAC2.14, IMU1.2, IMU1.9, IMU1.10, R2.1, R6.1, R10.1, R18.1, R22.1, R26.1, R29.2, Reg1.2
+5V: C2.1, Reg1.3, SWD1.3
/CAN/CAN_HI: CAN_TR1.7, SWD1.1
/CAN/CAN_LO: CAN_TR1.6, SWD1.2
/CAN/CAN_RX: Accel_mc1.61, CAN_TR1.4
/CAN/CAN_TX: Accel_mc1.62, CAN_TR1.1
/Controller/Bottom_left_FSR_out: AMP1.8, Accel_mc1.16, C8.2, R20.2
/Controller/Bottom_right_FSR_out: AMP2.7, Accel_mc1.10, C16.2, R32.2
/Controller/Break_FSR_OUT: AMP2.8, Accel_mc1.17, C14.2, R24.2
/Controller/IMU_data_ready: Accel_mc1.3, IMU1.12
/Controller/NRST: Accel_mc1.7, BUSCNT1.5, C17.1
/Controller/SCL: Accel_mc1.58, R14.2, R16.2, R34.2
/Controller/SDA: Accel_mc1.59, R12.2, R13.2, R33.2
/Controller/SWCLK: Accel_mc1.49, BUSCNT1.2
/Controller/SWDIO: Accel_mc1.46, BUSCNT1.4
/FSR_Circuitry/+break_ref: AMP2.10, R17.2, R18.2, R19.1
/FSR_Circuitry/+ref1: AMP1.3, R1.2, R2.2, R3.1
/FSR_Circuitry/+ref2: AMP1.5, R5.2, R6.2, R7.1
/FSR_Circuitry/+ref3: AMP1.10, R9.2, R10.2, R11.1
/FSR_Circuitry/+ref4: AMP2.12, R29.1, R30.1, R31.1
/FSR_Circuitry/+ref5: AMP2.3, R21.2, R22.2, R23.1
/FSR_Circuitry/+ref6: AMP2.5, R25.2, R26.2, R27.1
/FSR_Circuitry/-break_ref: AMP2.9, C14.1, J9.1, R24.1
/FSR_Circuitry/-ref1: AMP1.2, C6.1, J3.1, R8.1
/FSR_Circuitry/-ref2: AMP1.6, C7.1, J4.1, R15.1
/FSR_Circuitry/-ref3: AMP1.9, C8.1, J5.1, R20.1
/FSR_Circuitry/-ref4: AMP2.13, C5.1, J6.1, R4.1
/FSR_Circuitry/-ref5: AMP2.2, C15.1, J7.1, R28.1
/FSR_Circuitry/-ref6: AMP2.6, C16.1, J8.1, R32.1
/FSR_Circuitry/FSR_out1: AMP1.1, Accel_mc1.14, C6.2, R8.2
/FSR_Circuitry/FSR_out2: AMP1.7, Accel_mc1.15, C7.2, R15.2
/FSR_Circuitry/FSR_out4: AMP2.14, Accel_mc1.8, C5.2, R4.2
/FSR_Circuitry/FSR_out5: AMP2.1, Accel_mc1.9, C15.2, R28.2
/FSR_Circuitry/break_DAC: DAC2.5, R17.1
/FSR_Circuitry/dac_1: DAC1.2, R1.1
/FSR_Circuitry/dac_2: DAC1.3, R5.1
/FSR_Circuitry/dac_3: DAC1.5, R9.1
/FSR_Circuitry/dac_4: DAC2.6, R30.2
/FSR_Circuitry/dac_5: DAC2.2, R21.1
/FSR_Circuitry/dac_6: DAC2.3, R25.1
GND: AMP1.11, AMP1.13, AMP2.11, Accel_mc1.12, Accel_mc1.18, Accel_mc1.63, BUSCNT1.3, C1.2, C2.2, C3.2, C4.2, C9.2, C10.2, C11.2, C12.2, C13.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, CAN_TR1.2, DAC1.4, DAC1.8, DAC1.9, DAC2.4, DAC2.9, IMU1.3, IMU1.6, IMU1.7, IMU1.8, J10.1, J11.1, J12.1, J13.1, J14.1, J15.1, J16.1, R3.2, R7.2, R11.2, R19.2, R23.2, R27.2, R31.2, Reg1.1, SWD1.4
unnamed: Accel_mc1.31, C24.1
unnamed: Accel_mc1.47, C27.1
unnamed: DAC1.10, R12.1
unnamed: DAC1.11, R14.1
unnamed: DAC2.10, R13.1
unnamed: DAC2.11, R16.1
unnamed: IMU1.1, R34.1
unnamed: IMU1.4, R33.1

## Code that names these connections

File Code/configuration_DSC/configuration_DSC.ioc (part):

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Mcu.Name=STM32F765V(G-I)Tx
Mcu.Package=LQFP100
Mcu.UserName=STM32F765VITx
PA1.GPIOParameters=GPIO_Label
PA1.GPIO_Label=phase_1_curr
PA1.Signal=ADCx_IN1
PA11.Mode=Master
PA11.Signal=CAN1_RX
PA12.Mode=Master
PA12.Signal=CAN1_TX
PA13.Signal=SYS_JTMS-SWDIO
PA14.Signal=SYS_JTCK-SWCLK
PA15.GPIOParameters=GPIO_PuPd
PA15.GPIO_PuPd=GPIO_PULLDOWN
PA15.Signal=GPIO_Input
PA2.GPIOParameters=GPIO_Label
PA2.GPIO_Label=phase_2_curr
PA2.Signal=ADCx_IN2
PA3.GPIOParameters=GPIO_PuPd
PA3.GPIO_PuPd=GPIO_PULLDOWN
PA3.Signal=GPIO_Input
PA4.GPIOParameters=GPIO_Label
PA4.GPIO_Label=phase_3_curr
PA4.Signal=ADCx_IN4
PA5.GPIOParameters=GPIO_Label
PA5.GPIO_Label=V_battery_supply
PA5.Signal=ADCx_IN5
PB10.Mode=I2C
PB10.Signal=I2C2_SCL
PB11.Mode=I2C
PB11.Signal=I2C2_SDA
PB12.GPIOParameters=GPIO_PuPd
PB12.GPIO_PuPd=GPIO_PULLDOWN
PB12.Signal=GPIO_Input
PB2.GPIOParameters=GPIO_PuPd
PB2.GPIO_PuPd=GPIO_PULLDOWN
PB2.Signal=GPIO_Input
PB3.GPIOParameters=GPIO_PuPd
PB3.GPIO_PuPd=GPIO_PULLDOWN
PB3.Signal=GPIO_Input
PB4.GPIOParameters=GPIO_PuPd
PB4.GPIO_PuPd=GPIO_PULLDOWN
PB4.Signal=GPIO_Input
PB5.GPIOParameters=GPIO_PuPd
PB5.GPIO_PuPd=GPIO_PULLDOWN
PB5.Signal=GPIO_Input
PB6.GPIOParameters=GPIO_PuPd
PB6.GPIO_PuPd=GPIO_PULLDOWN
PB6.Signal=GPIO_Input
PB7.GPIOParameters=GPIO_PuPd
PB7.GPIO_PuPd=GPIO_PULLDOWN
PB7.Signal=GPIO_Input
PB8.GPIOParameters=GPIO_PuPd
PB8.GPIO_PuPd=GPIO_PULLDOWN
PB8.Signal=GPIO_Input
PB9.GPIOParameters=GPIO_PuPd
PB9.GPIO_PuPd=GPIO_PULLDOWN
PB9.Signal=GPIO_Input
PC0.GPIOParameters=GPIO_Label
PC0.GPIO_Label=V_phase_1
PC0.Signal=ADCx_IN10
PC1.GPIOParameters=GPIO_Label
PC1.GPIO_Label=V_phase_2
PC1.Signal=ADCx_IN11
PC10.GPIOParameters=GPIO_PuPd
PC10.GPIO_PuPd=GPIO_PULLDOWN
PC10.Signal=GPIO_Input
PC11.GPIOParameters=GPIO_PuPd
PC11.GPIO_PuPd=GPIO_PULLDOWN
PC11.Signal=GPIO_Input
PC12.GPIOParameters=GPIO_PuPd
PC12.GPIO_PuPd=GPIO_PULLDOWN
PC12.Signal=GPIO_Input
PC13.GPIOParameters=GPIO_PuPd
PC13.GPIO_PuPd=GPIO_PULLDOWN
PC13.Signal=GPIO_Input
PC14/OSC32_IN.GPIOParameters=GPIO_PuPd,GPIO_Label
PC14/OSC32_IN.GPIO_Label=LED_GREEN
PC14/OSC32_IN.GPIO_PuPd=GPIO_PULLUP
PC14/OSC32_IN.Signal=GPIO_Output
PC15/OSC32_OUT.GPIOParameters=GPIO_PuPd,GPIO_Label
PC15/OSC32_OUT.GPIO_Label=LED_RED
PC15/OSC32_OUT.GPIO_PuPd=GPIO_PULLUP
PC15/OSC32_OUT.Signal=GPIO_Output
PC2.GPIOParameters=GPIO_Label
PC2.GPIO_Label=V_phase_3
PC2.Signal=ADCx_IN12
PC3.GPIOParameters=GPIO_Label
PC3.GPIO_Label=Pfet_temp
PC3.Signal=ADCx_IN13
PC4.GPIOParameters=GPIO_PuPd
PC4.GPIO_PuPd=GPIO_PULLDOWN
PC4.Signal=GPIO_Input
PC5.GPIOParameters=GPIO_PuPd
PC5.GPIO_PuPd=GPIO_PULLDOWN
PC5.Signal=GPIO_Input
PC6.Signal=S_TIM8_CH1
PC9.GPIOParameters=GPIO_PuPd
PC9.GPIO_PuPd=GPIO_PULLDOWN
PC9.Signal=GPIO_Input
PD10.GPIOParameters=GPIO_PuPd
PD10.GPIO_PuPd=GPIO_PULLDOWN
PD10.Signal=GPIO_Input
PD11.GPIOParameters=GPIO_PuPd
PD11.GPIO_PuPd=GPIO_PULLDOWN
PD11.Signal=GPIO_Input
PD12.GPIOParameters=GPIO_PuPd
PD12.GPIO_PuPd=GPIO_PULLDOWN
PD12.Signal=GPIO_Input
PD13.GPIOParameters=GPIO_PuPd
PD13.GPIO_PuPd=GPIO_PULLDOWN
PD13.Signal=GPIO_Input
PD14.Signal=GPIO_Input
PD15.GPIOParameters=GPIO_PuPd
PD15.GPIO_PuPd=GPIO_PULLDOWN
PD15.Signal=GPIO_Input
PD2.GPIOParameters=GPIO_PuPd
PD2.GPIO_PuPd=GPIO_PULLDOWN
PD2.Signal=GPIO_Input
PD3.GPIOParameters=GPIO_PuPd
PD3.GPIO_PuPd=GPIO_PULLDOWN
PD3.Signal=GPIO_Input
PD4.GPIOParameters=GPIO_PuPd
PD4.GPIO_PuPd=GPIO_PULLDOWN
PD4.Signal=GPIO_Input
PD5.GPIOParameters=GPIO_PuPd
PD5.GPIO_PuPd=GPIO_PULLDOWN
PD5.Signal=GPIO_Input
PD6.GPIOParameters=GPIO_PuPd
PD6.GPIO_PuPd=GPIO_PULLDOWN
PD6.Signal=GPIO_Input
PD7.GPIOParameters=GPIO_PuPd
PD7.GPIO_PuPd=GPIO_PULLDOWN
PD7.Signal=GPIO_Input
PD8.GPIOParameters=GPIO_PuPd
PD8.GPIO_PuPd=GPIO_PULLDOWN
PD8.Signal=GPIO_Input
PD9.GPIOParameters=GPIO_PuPd
PD9.GPIO_PuPd=GPIO_PULLDOWN
PD9.Signal=GPIO_Input
PE0.GPIOParameters=GPIO_PuPd
PE0.GPIO_PuPd=GPIO_PULLDOWN
PE0.Signal=GPIO_Input
PE1.GPIOParameters=GPIO_PuPd
PE1.GPIO_PuPd=GPIO_PULLDOWN
PE1.Signal=GPIO_Input
PE10.GPIOParameters=GPIO_Label
PE10.GPIO_Label=INL2
PE10.Mode=PWM Generation2 CH2 CH2N
PE10.Signal=TIM1_CH2N
PE11.GPIOParameters=GPIO_Label
PE11.GPIO_Label=INH2
PE11.Signal=S_TIM1_CH2
PE12.GPIOParameters=GPIO_Label
PE12.GPIO_Label=INL3
PE12.Mode=PWM Generation3 CH3 CH3N
PE12.Signal=TIM1_CH3N
PE13.GPIOParameters=GPIO_Label
PE13.GPIO_Label=INH3
PE13.Signal=S_TIM1_CH3
PE14.GPIOParameters=GPIO_PuPd,GPIO_Label
PE14.GPIO_Label=En_Gate
PE14.GPIO_PuPd=GPIO_PULLUP
PE14.Signal=GPIO_Output
PE15.GPIOParameters=GPIO_PuPd,GPIO_Label
PE15.GPIO_Label=Fault
PE15.GPIO_PuPd=GPIO_PULLUP
PE15.Signal=GPIO_Input
PE2.GPIOParameters=GPIO_PuPd
PE2.GPIO_PuPd=GPIO_PULLDOWN
PE2.Signal=GPIO_Input
PE3.GPIOParameters=GPIO_PuPd
PE3.GPIO_PuPd=GPIO_PULLDOWN
PE3.Signal=GPIO_Input
PE4.GPIOParameters=GPIO_PuPd
PE4.GPIO_PuPd=GPIO_PULLDOWN
PE4.Signal=GPIO_Input
PE5.GPIOParameters=GPIO_PuPd
PE5.GPIO_PuPd=GPIO_PULLDOWN
PE5.Signal=GPIO_Input
PE6.GPIOParameters=GPIO_PuPd
PE6.GPIO_PuPd=GPIO_PULLDOWN
PE6.Signal=GPIO_Input
PE8.GPIOParameters=GPIO_Label
PE8.GPIO_Label=INL1
PE8.Mode=PWM Generation1 CH1 CH1N
PE8.Signal=TIM1_CH1N
PE9.GPIOParameters=GPIO_Label
PE9.GPIO_Label=INH1
PE9.Signal=S_TIM1_CH1
PH0/OSC_IN.GPIOParameters=GPIO_PuPd
PH0/OSC_IN.GPIO_PuPd=GPIO_PULLDOWN
PH0/OSC_IN.Signal=GPIO_Input
PH1/OSC_OUT.GPIOParameters=GPIO_PuPd
PH1/OSC_OUT.GPIO_PuPd=GPIO_PULLDOWN
PH1/OSC_OUT.Signal=GPIO_Input
RCC.HSE_VALUE=25000000
board=custom

## Commit log

2019-06-05 Initial setup including all work done so far Models for motor control PCB, Text schematic and BMS for same :
2019-06-22 Removed SVN and code blocks code folder
2019-06-27 updated motor control pcb text document, motor control BMS. Begining of motor control coding project.
2019-06-27 remove duplicate and uncessary files
2019-06-27 removed svn
2019-07-20 added Simulink project for modeling FOC algorithm modified motor control pcb notes and BOM to use 4 330UF aluminum electrolytic capacitors (EEE-FT1H331AP) in place of 2 680 UF capacitors (EEV-FK1J681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
2019-08-06 Completed first iteration of PCB design for the BLDC motor controller Completed schematic stored symbol, footprint and model libraries in a convient location for ease of access in the program. Altere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
2019-08-06 Updated PCB
2019-08-07 Add files via upload
    pcb work done on work computer
2019-08-08 PCB version that will be given to Eric's friend for review
2019-09-11 updated pcb files, deleted redundant code files"
2019-09-30 updated all files
2019-10-09 reogranized file locations, improved DSC controller pcb with edged margin on edges and rounded corners. Completed Acceleration control board schematic
2019-10-20 nearly completed forward acceleration control board rounded edges and established clearence for motor control board made progress canabalizing Vedder's code for motor control
2019-10-25 Code and PCB modifications
    Adjustments to DSC motor controller PCB as well as BOMs
    Nearly completed cannibalization of VESC code for the DSC motor control
    application.
2019-11-01 safety
2019-11-14 replaced 220nf resistor with component that fit, moved silkscreen around, updated BOM
2019-11-22 updated BOMS for boards and added battery pack wiring schematic
