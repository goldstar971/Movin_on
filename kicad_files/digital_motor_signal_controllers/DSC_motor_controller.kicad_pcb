# Repository goldstar971/Movin_on

## KiCad design kicad_files/digital_motor_signal_controllers/DSC_motor_controller.kicad_pcb

Parts:
BUSCNT1: CAN; SM04B-PASS-TBT; Manufacturer_Part_Number SM04B-PASS-TBT(LF)(SN)
C46: .1u; CAPC2012X145N; Manufacturer_Part_Number AS0805KKX7R0BB104; Mouser Part Number 603-AS0805KKX70BB104
D2: Green; LEDC1608X55N; Manufacturer_Part_Number LTST-C191KGKT; Mouser Part Number 859-LTST-C191KGKT
D3: Red; LEDC1608X55N; Manufacturer_Part_Number LTST-C191KRKT; Mouser Part Number 859-LTST-C191KRKT
R1, R2: 100R; RESC1608X55N; Manufacturer_Part_Number RK73H1JTTD1000F; Mouser Part Number 660-RK73H1JTTD1000F
RECV1: ALT_Control; SM04B-PASS-TBT; Manufacturer_Part_Number SM04B-PASS-TBT(LF)(SN)
SWD1: SWD; SM05BPASSTBTLFSN; Manufacturer_Part_Number SM05B-PASS-TBT(LF)(SN)

Connections:
+3V3: SWD1.1; also elsewhere on the board
+5V: BUSCNT1.3, RECV1.3; also elsewhere on the board
/CAN/CAN_HI: BUSCNT1.1; also elsewhere on the board
/CAN/CAN_LO: BUSCNT1.2; also elsewhere on the board
/Motor_controller/LED_Green: D2.2 (A); also elsewhere on the board
/Motor_controller/LED_Red: D3.2 (A); also elsewhere on the board
/Motor_controller/NRST: C46.1, SWD1.5; also elsewhere on the board
/Motor_controller/SCL: RECV1.1; also elsewhere on the board
/Motor_controller/SDA: RECV1.2; also elsewhere on the board
/Motor_controller/SWCLK: SWD1.2; also elsewhere on the board
/Motor_controller/SWDIO: SWD1.4; also elsewhere on the board
GND: BUSCNT1.4, C46.2, R1.1, R2.1, RECV1.4, SWD1.3; also elsewhere on the board
unnamed: D2.1 (K), R1.2
unnamed: D3.1 (K), R2.2

Parts:
C35: 1u; CAPC1005X55N; Manufacturer_Part_Number GRM155C81C105ME11J; Mouser Part Number 81-GRM155C81C105ME1J
C36, C37: 2.2u; CAPC3216X180N; Manufacturer_Part_Number C3216X7R1H225K160AE; Mouser Part Number 810-C3216X7R1H225KST
C38: 4.7u; CAPC3225X200N; Manufacturer_Part_Number CGA6M3X7S2A475K200AB; Mouser Part Number 810-CGA6M3X7S2A475K
C39, C40, C41, C42, C43, C44, C45: 100n; CAPC2012X145N; Manufacturer_Part_Number AS0805KKX7R0BB104; Mouser Part Number 603-AS0805KKX70BB104
DSC1: STM32F765VIT6; QFP50P1600X1600X160-100N; Manufacturer_Part_Number STM32F765VIT6; Mouser Part Number 511-STM32F765VIT6

Connections:
+3V3: C35.1, C38.1, C39.1, C40.1, C41.1, C42.1, C43.1, C44.1, C45.1, DSC1.6 (VBAT), DSC1.11 (VDD1), DSC1.20 (VREF+), DSC1.21 (VDDA), DSC1.27 (VDD2), DSC1.50 (VDD3), DSC1.75 (VDD4), DSC1.100 (VDD5); also elsewhere on the board
/CAN/CAN_RX: DSC1.70 (PA11); also elsewhere on the board
/CAN/CAN_TX: DSC1.71 (PA12); also elsewhere on the board
/Motor_Driver/Batt_voltage: DSC1.18 (PC3); also elsewhere on the board
/Motor_Driver/EN_GATE: DSC1.44 (PE14); also elsewhere on the board
/Motor_Driver/FAULT: DSC1.45 (PE15); also elsewhere on the board
/Motor_Driver/PWM_A_H: DSC1.43 (PE13); also elsewhere on the board
/Motor_Driver/PWM_A_L: DSC1.42 (PE12); also elsewhere on the board
/Motor_Driver/PWM_B_H: DSC1.41 (PE11); also elsewhere on the board
/Motor_Driver/PWM_B_L: DSC1.40 (PE10); also elsewhere on the board
/Motor_Driver/PWM_C_H: DSC1.39 (PE9); also elsewhere on the board
/Motor_Driver/PWM_C_L: DSC1.38 (PE8); also elsewhere on the board
/Motor_Driver/Volt_A: DSC1.23 (PA1); also elsewhere on the board
/Motor_Driver/Volt_B: DSC1.24 (PA2); also elsewhere on the board
/Motor_Driver/Volt_C: DSC1.28 (PA4); also elsewhere on the board
/Motor_controller/Curr_A: DSC1.15 (PC0); also elsewhere on the board
/Motor_controller/Curr_B: DSC1.16 (PC1); also elsewhere on the board
/Motor_controller/Curr_C: DSC1.17 (PC2); also elsewhere on the board
/Motor_controller/LED_Green: DSC1.8 (PC14-OSC32_IN); also elsewhere on the board
/Motor_controller/LED_Red: DSC1.9 (PC15-OSC32_OUT); also elsewhere on the board
/Motor_controller/NRST: DSC1.14 (NRST); also elsewhere on the board
/Motor_controller/SCL: DSC1.46 (PB10); also elsewhere on the board
/Motor_controller/SDA: DSC1.47 (PB11); also elsewhere on the board
/Motor_controller/SWCLK: DSC1.76 (PA14); also elsewhere on the board
/Motor_controller/SWDIO: DSC1.72 (PA13); also elsewhere on the board
/Motor_controller/Temp_sense: DSC1.29 (PA5); also elsewhere on the board
GND: C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C43.2, C44.2, C45.2, DSC1.10 (VSS1), DSC1.19 (VSSA), DSC1.49 (VSS3), DSC1.74 (VSS4), DSC1.94 (BOOT0), DSC1.99 (VSS5); also elsewhere on the board
unnamed: C36.1, DSC1.48 (VCAP1)
unnamed: C37.1, DSC1.73 (VCAP2)
unnamed: C42.2, DSC1.26 (VSS2)

Parts:
C1: 100n; CAPC2012X145N; Manufacturer_Part_Number AS0805KKX7R0BB104; Mouser Part Number 603-AS0805KKX70BB104
CAN_TR1: SN65HVD232DR; SOIC127P600X175-8N; Manufacturer_Part_Number SN65HVD232DR; Mouser Part Number 595-SN65HVD232DR
RTERM1: 120R; RESC1608X55N; Manufacturer_Part_Number ERA3AEB121V

Connections:
+3V3: C1.1, CAN_TR1.3 (GND_2); also elsewhere on the board
/CAN/CAN_HI: CAN_TR1.7 (CANH), RTERM1.2; also elsewhere on the board
/CAN/CAN_LO: CAN_TR1.6 (CANL), RTERM1.1; also elsewhere on the board
/CAN/CAN_RX: CAN_TR1.4 (R); also elsewhere on the board
/CAN/CAN_TX: CAN_TR1.1 (D); also elsewhere on the board
GND: C1.2, CAN_TR1.2 (GND_1); also elsewhere on the board

Parts:
C2, C3: 1u; CAPC1005X55N; Manufacturer_Part_Number GRM155C81C105ME11J; Mouser Part Number 81-GRM155C81C105ME1J
C19: 6.8n; CAPC1608X90N; Manufacturer_Part_Number CGA3E2C0G1H682J080AD; Mouser Part Number 810-CGA3E2C0G1H682JD
C20: 120p; CAPC1608X87N; Manufacturer_Part_Number C0603C121J5GACTU; Mouser Part Number 80-C0603C121J5G
C21: 22n; CAPC1608X90N; Manufacturer_Part_Number CGA3E2X7R1H223K080AA; Mouser Part Number 810-CGA3E2X7R1H223K
C22, C23, C24, C25, C26: 2.2u; CAPC3216X180N; Manufacturer_Part_Number C3216X7R1H225K160AE; Mouser Part Number 810-C3216X7R1H225KST
C27, C28, C29: 220n; CAPC1005X55N; Manufacturer_Part_Number CGA2B3X7R1E224K050BE; Mouser Part Number 810-CG2B3X7R1E224KBE
C30: 100n; CAPC2012X145N; Manufacturer_Part_Number AS0805KKX7R0BB104; Mouser Part Number 603-AS0805KKX70BB104
C31: 15n; CAPC1608X87N; Manufacturer_Part_Number C0603C153J3GACTU; Mouser Part Number 80-C0603C153J3G
C32, C33: 4.7u; CAPC3225X200N; Manufacturer_Part_Number CGA6M3X7S2A475K200AB; Mouser Part Number 810-CGA6M3X7S2A475K
C34: 100u; CAPPM7343X200N; Manufacturer_Part_Number 875015119003; Mouser Part Number 710-875015119003
D1: PMEG6020ER,115; SODFL3517X110N; Manufacturer_Part_Number PMEG6020ER,115; Mouser Part Number 771-PMEG6020ER-115
D4: TVS; DIOM5026X229N; Mouser Part Number 576-SMAJ5.0A
DRV1: DRV8302; SOP50P810X120-57N
L1: 22u; SDR0805-121KL; Manufacturer_Part_Number SDR0805-220ML; Mouser Part Number 652-SDR0805-220ML
R16: 3.3K; RESC1608X55N; Manufacturer_Part_Number RK73H1JTTD3301F; Mouser Part Number 660-RK73H1JTTD3301F
R17: 18k; RESC1608X55N; Manufacturer_Part_Number RK73H1JTTD1802F; Mouser Part Number 660-RK73H1JTTD1802F
R18: 15k; RESC1608X55N; Manufacturer_Part_Number RK73H1JTTD1502F; Mouser Part Number 660-RK73H1JTTD1502F
R19: 220k; RESC1608X55N; Manufacturer_Part_Number RK73H1JTTD2203F; Mouser Part Number 660-RK73H1JTTD2203F
R20: 1M; RESC1608X55N; Manufacturer_Part_Number RK73H1JTTD1004F; Mouser Part Number 660-RK73H1JTTD1004F
R21: 10k; RESC1608X55N; Manufacturer_Part_Number RK73H1JTTD1002F; Mouser Part Number 660-RK73H1JTTD1002F
R22, R23, R24, R25: 2k2; RESC1608X55N; Manufacturer_Part_Number RK73H1JTTD2201F; Mouser Part Number 660-RK73H1JTTD2201F
R26, R27, R28, R29: 39k; RESC1608X55N; Manufacturer_Part_Number ERJ3EKF3902V
Reg1: TC2117; SOT230P700X180-4N; Manufacturer_Part_Number TC2117-3.3VDBTR; Mouser Part Number 579-TC2117-3.3VDBTR

Connections:
+3V3: C3.1, DRV1.9 (M_OC), Reg1.2 (VOUT_1); also elsewhere on the board
+5V: C2.1, C26.1, C34.1, D4.1, L1.2, R17.1, Reg1.3 (VIN); also elsewhere on the board
/Motor_Driver/Batt_voltage: R25.2, R29.1; also elsewhere on the board
/Motor_Driver/EN_GATE: DRV1.16 (EN_GATE); also elsewhere on the board
/Motor_Driver/FAULT: DRV1.6 (NFAULT); also elsewhere on the board
/Motor_Driver/GH_A: DRV1.47 (GH_A); also elsewhere on the board
/Motor_Driver/GH_B: DRV1.42 (GH_B); also elsewhere on the board
/Motor_Driver/GH_C: DRV1.37 (GH_C); also elsewhere on the board
/Motor_Driver/GL_A: DRV1.45 (GL_A); also elsewhere on the board
/Motor_Driver/GL_B: DRV1.40 (GL_B); also elsewhere on the board
/Motor_Driver/GL_C: DRV1.35 (GL_C); also elsewhere on the board
/Motor_Driver/PWM_A_H: DRV1.17 (INH_A); also elsewhere on the board
/Motor_Driver/PWM_A_L: DRV1.18 (INL_A); also elsewhere on the board
/Motor_Driver/PWM_B_H: DRV1.19 (INH_B); also elsewhere on the board
/Motor_Driver/PWM_B_L: DRV1.20 (INL_B); also elsewhere on the board
/Motor_Driver/PWM_C_H: DRV1.21 (INH_C); also elsewhere on the board
/Motor_Driver/PWM_C_L: DRV1.22 (INL_C); also elsewhere on the board
/Motor_Driver/SH_A: C29.2, DRV1.46 (SH_A), R26.2; also elsewhere on the board
/Motor_Driver/SH_B: C28.2, DRV1.41 (SH_B), R27.2; also elsewhere on the board
/Motor_Driver/SH_C: C27.2, DRV1.36 (SH_C), R28.2; also elsewhere on the board
/Motor_Driver/Volt_A: R22.2, R26.1; also elsewhere on the board
/Motor_Driver/Volt_B: R23.2, R27.1; also elsewhere on the board
/Motor_Driver/Volt_C: R24.2, R28.1; also elsewhere on the board
GND: C2.2, C3.2, C19.2, C20.2, C22.2, C23.2, C24.2, C25.2, C26.2, C31.1, C32.2, C33.2, C34.2, D1.2, D4.2, DRV1.4 (PWRGD), DRV1.8 (M_PWM), DRV1.10 (GAIN), DRV1.24 (REF), DRV1.28 (AGND), DRV1.30 (SP2), DRV1.31 (SN2), DRV1.32 (SP1), DRV1.33 (SN1), DRV1.34 (SL_C), DRV1.39 (SL_B), DRV1.44 (SL_A), DRV1.57 (GND), R16.2, R19.2, R20.2, R21.2, R22.1, R23.1, R24.1, R25.1, Reg1.1 (GND); also elsewhere on the board
unnamed: C19.1, R18.2
unnamed: C20.1, DRV1.2 (COMP), R18.1
unnamed: C21.1, DRV1.14 (CP1)
unnamed: C21.2, DRV1.15 (CP2)
unnamed: C22.1, DRV1.27 (AVDD)
unnamed: C23.1, DRV1.23 (DVDD)
unnamed: C24.1, DRV1.11 (OC_ADJ)
unnamed: C25.1, DRV1.13 (GVDD)
unnamed: C27.1, DRV1.38 (BST_C)
unnamed: C28.1, DRV1.43 (BST_B)
unnamed: C29.1, DRV1.48 (BST_A)
unnamed: C30.1, DRV1.52 (BST_BK)
unnamed: C30.2, D1.1, DRV1.50 (PH_1), DRV1.51 (PH_2), L1.1
unnamed: C31.2, DRV1.56 (SS_TR)
unnamed: DRV1.1 (RT_CLK), R19.1
unnamed: DRV1.3 (VSENSE), R16.1, R17.2
unnamed: DRV1.7 (DTC), R21.1
unnamed: DRV1.49 (BIAS), R20.1
SUPPLY: C32.1, C33.1, DRV1.29 (PVDD1), DRV1.53 (PVDD2_1), DRV1.54 (PVDD2_2), R29.2; also elsewhere on the board

Parts:
C4, C5, C6, C7, C8, C9: 4.7u; CAPC3225X200N; Manufacturer_Part_Number CGA6M3X7S2A475K200AB; Mouser Part Number 810-CGA6M3X7S2A475K
C10, C11, C12: 4.7n; CAPC1005X55N; Manufacturer_Part_Number GCM155R71H472KA37D; Mouser Part Number 81-GCM155R71H472K37D
C13, C14, C15, C16: 2.2u; CAPC3216X180N; Manufacturer_Part_Number C3216X7R1H225K160AE; Mouser Part Number 810-C3216X7R1H225KST
C17, C18: 1000u; CAPPRD500W60D1275H2700; Mouser Part Number 647-UVR1H102MHD1T0
CS1, CS2, CS3: AD8418ABRMZ; SOP65P490X110-8N; Manufacturer_Part_Number AD8418ABRMZ; Mouser Part Number 584-AD8418ABRMZ
P1: PH_A; SolderWirePad_1x01_SMD_5x10mm
P2: PH_B; SolderWirePad_1x01_SMD_5x10mm
P3: PH_C; SolderWirePad_1x01_SMD_5x10mm
P4: SUPPLY; SolderWirePad_1x01_SMD_5x10mm
P5: GND; SolderWirePad_1x01_SMD_5x10mm
Q1, Q2, Q3, Q4, Q5, Q6: IRFS7730TRLPBF; D2PAK(TO-263AB); Manufacturer_Part_Number IRFS7730TRLPBF; Mouser Part Number 942-IRFS7730TRLPBF
R3, R4, R5, R6, R7, R8: 4.7R; RESC1608X55N; Manufacturer_Part_Number RK73H1JTTD4R70F; Mouser Part Number 660-RK73H1JTTD4R70F
R9, R10, R11: .001R; WSLP2726; Manufacturer_Part_Number WSLP27261L000FEA; Mouser Part Number 71-WSLP27261L000FEA
R12, R13, R14: 100R; RESC1608X55N; Manufacturer_Part_Number RK73H1JTTD1000F; Mouser Part Number 660-RK73H1JTTD1000F
R15: 10k; RESC1608X55N; Manufacturer_Part_Number RK73H1JTTD1002F; Mouser Part Number 660-RK73H1JTTD1002F
RTEMP1: NTC 10k; THRMC1608X95N; Manufacturer_Part_Number NCP18XH103F03RB; Mouser Part Number 81-NCP18XH103F03RB

Connections:
+3V3: C13.1, C14.2, C15.2, CS1.6 (VS), CS1.7 (VREF1), CS2.6 (VS), CS2.7 (VREF1), CS3.6 (VS), CS3.7 (VREF1), RTEMP1.1; also elsewhere on the board
/Motor_Driver/GH_A: R3.1; also elsewhere on the board
/Motor_Driver/GH_B: R5.1; also elsewhere on the board
/Motor_Driver/GH_C: R7.1; also elsewhere on the board
/Motor_Driver/GL_A: R4.1; also elsewhere on the board
/Motor_Driver/GL_B: R6.1; also elsewhere on the board
/Motor_Driver/GL_C: R8.1; also elsewhere on the board
/Motor_Driver/SH_A: Q1.2, Q2.3, R9.2; also elsewhere on the board
/Motor_Driver/SH_B: Q3.2, Q4.3, R10.2; also elsewhere on the board
/Motor_Driver/SH_C: Q5.2, Q6.3, R11.2; also elsewhere on the board
/Motor_controller/Curr_A: C10.1, R12.2; also elsewhere on the board
/Motor_controller/Curr_B: C11.1, R13.2; also elsewhere on the board
/Motor_controller/Curr_C: C12.1, R14.2; also elsewhere on the board
/Motor_controller/Temp_sense: C16.1, R15.1, RTEMP1.2; also elsewhere on the board
/Power/C_A: CS1.5 (OUT), R12.1
/Power/C_B: CS2.5 (OUT), R13.1
/Power/C_C: CS3.5 (OUT), R14.1
GND: C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.1, C15.1, C16.2, C17.2, C18.2, CS1.2 (GND), CS1.3 (VREF2), CS2.2 (GND), CS2.3 (VREF2), CS3.2 (GND), CS3.3 (VREF2), P5.1, Q2.2, Q4.2, Q6.2, R15.2; also elsewhere on the board
unnamed: CS1.1 (-IN), R9.3
unnamed: CS1.8 (+IN), R9.4
unnamed: CS2.1 (-IN), R10.3
unnamed: CS2.8 (+IN), R10.4
unnamed: CS3.1 (-IN), R11.3
unnamed: CS3.8 (+IN), R11.4
unnamed: P1.1, R9.1
unnamed: P2.1, R10.1
unnamed: P3.1, R11.1
unnamed: Q1.1, R3.2
unnamed: Q2.1, R4.2
unnamed: Q3.1, R5.2
unnamed: Q4.1, R6.2
unnamed: Q5.1, R7.2
unnamed: Q6.1, R8.2
SUPPLY: C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C17.1, C18.1, P4.1, Q1.3, Q3.3, Q5.3; also elsewhere on the board

Board: 4 copper layers, 106.0 x 108.4 mm, 107 parts (28 on the bottom side), 81 nets.

Other parts of the board:
h1, h2, h3, h4: MountingHole_4.3mm_M4

File kicad_files/DSC_motor_controller_BOM.csv:

Item #,*Ref Des,*Qty,Manufacturer,*Mfg Part #,Description / Value,*Package,Type
1,10,"C1, C30, C39, C40, C41, C42, C43, C44, C45,C46",Yageo,AS0805KKX7R0BB104,100 nF,805,SMD
2,3,"C10, C11, C12",Murata,GCM155R71H472KA37D ,4.7nF 50V,0402,SMD
3,11,"C13, C14, C15, C16, C22, C23, C24, C25, C26, C36, C37",TDK ,C3216X7R1H225K160AE ,2.2 uf,1206,SMD
4,2,"C17, C18", Nichicon,UVR1H102MHD1TO,1mF radial aluminum electrolytic capacitors ,N\a,DNS
5,1,C19,TDK ,CGA3E2C0G1H682J080AD,6.8 nf,0603,SMD
6,3,"C2, C3, C35",Murata,GRM155C81C105ME11J,1 uf,0402,SMD
7,1,C20,KEMET,C0603C121J5GACTU,120 pf,0603,SMD
8,1,C21,TDK ,CGA3E2X7R1H223K080AA,22 nf,0603,SMD
9,3,"C27, C28, C29",KEMET,C0805C224J5NACTU ,220 nf,0805,SMD
10,1,C31,Wurth Electronics,875015119003,100uf aluminum organic polymer,n\a,SMD
11,1,C34,KEMET,C0603C153J3GACTU ,15 nf,0603,SMD
12,9,"C4, C5, C6, C7, C8, C9, C32, C33, C38",TDK ,CGA6M3X7S2A475K200AB,4.7 UF 100V ,1210,SMD
13,1,CAN_TR,Texas Instruments,SN65HVD232DR,"CAN transceiver,",8-SOIC,SMD
14,3,"CS1, CS2, CS3",Analog Devices Inc.,AD8418ABRMZ ,"current sense amplifier, 100 DB CMRR 20 V/V gain, bidirectional, zero drift ",8-MSOP,SMD
15,1,D1,Nexperia USA Inc,PMEG6020ER-115 ,"Schottky diode, 60V 2A",SOD-123W,SMD
16,1,D2,Lite-On Inc.,LTST-C191KGKT,LED Green,0603,SMD
17,1,D3,Lite-On Inc.,LTST-C191KRKT,LED Red,0603,SMD
18,1,DRV,Texas Instruments,DRV8302DCAR,"3 Phase Motor Pre-driver, 1.5 amp buck converter, 2 high accuracy current sensors, ",HTSSOP-56,SMD
19,1,DSC,STMicroelectronics,STM32F765VIT6,"Cortex M7, 2MB FLASH, 216 MHz 32-bit CPU 512KB RAM, 140 GPIO,CAN",LQFP-100,SMD
20,1,L1,bourns,SDR0805-220ML ,Power inductor with L=22uh and 1.5 A max forward current,n\a,SMD
21,6,"Q1, Q2, Q3, Q4, Q5, Q6",infineon,IRFS7730TRLPBF,"1 Channel Power NMOS, 75 volt Vds, 195 A drain current ",TO-263-3 ,SMD
22,5,"R1, R2, R12, R13, R14",KOA Speer ,RK73H1JTTD1000F,100ohm,0603,SMD
23,2,"R15, R21",KOA Speer ,RK73H1JTTD1002F,10kohm,0603,SMD
24,1,R16,KOA Speer ,RK73H1JTTD3301F,3.3kohms,0603,SMD
25,1,R17,KOA Speer ,RK73H1JTTD1802F,18kohm,0603,SMD
26,1,R18,KOA Speer ,RK73H1JTTD1502F,15kohms,0603,SMD
27,1,R19,KOA Speer ,RK73H1JTTD2203F,220kohm,0603,SMD
28,1,R20,KOA Speer ,RK73H1JTTD1004F,1000kohm,0603,SMD
29,4,"R22, R23, R24, R25",KOA Speer ,RK73H1JTTD2201F,2.2kohms,0603,SMD
30,4,"R26, R27, R28, R29",Panasonic Electrical Components,ERJ-3EKF3902V,39 kohm resistor,0603,SMD
31,6,"R3, R4, R5, R6, R7, R8",KOA Speer ,RK73H1JTTD4R70F,R=4.7 ohms,0603,SMD
32,3,"R9, R10, R11",Vishay/ Dale,WSLP27261L000FEA,Shunt with resistance 1 mohm,n\a,SMD
33,2,"RECV, BUSCNT",JST Sales America Inc., SM04B-PASS-TBT(LF)(SN) ,"4 way, solderless terminal right angle shrouded male header,with 2mm pitch ",N\A,SMD
34,1,Reg,Microchip Technology,TC2117-3.3VDBTR,"Low noise, 3.3 volt, .8A regulator ",SOT-223-3 ,SMD
35,1,RTEMP,Murata,NCP18XH103F03RB,thermistors 10kohm 1%,0603,SMD
36,1,RTERM,Panasonic Electrical Components,ERA-3AEB121V ,120 ohm resistor,0603,SMD
37,1,SWD,JST Sales America Inc., SM05B-PASS-TBT(LF)(SN) ,"5 way, solderless terminal right angle shrouded male header,with 2mm pitch ",N\A,SMD
